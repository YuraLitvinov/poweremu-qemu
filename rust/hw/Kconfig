## rust/hw/Kconfig
```kconfig
# devices Kconfig
source char/Kconfig
source display/Kconfig
source timer/Kconfig
```
